Commit message: add missing files

File: src/hospital_robot/urdf/omni_base.urdf (robot description, URDF)
Before this commit: robot omni_base, 18 links, 17 joints
Links:
- link base_antenna_right_link: mass 0.02311 -> 0.0231
